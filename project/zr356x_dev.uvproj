# Keil uVision project zr356x_dev.uvproj, settings and files
target zr356x_dev (6160000::V6.16::ARMCLANG)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: zr356x_dev +hex
  AfterMake: fromelf.exe --bin -o "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe --text -a -c -o "$L..\@L.txt" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CUSTOMIZE_CFG,
  c misc: -mfloat-abi=soft -Wno-extra-semi-stmt -Wno-declaration-after-statement -Wno-padded  -Wno-covered-switch-default -Wno-cast-align -Wno-missing-variable-declarations -Wno-switch-enum -Wno-date-time
  c include: ..\app\inc;..\common\inc;..\lib\inc;..\policy\inc;..\common\inc;..\core\inc;..\system\inc;..\lib\inc;..\pd\inc;..\lenevo_sink\inc;..\user\inc;..\uvdm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group core
    ../core/src/: startup_CMSDK_CM0.s
  group project
    ./: main.c serial.c
  group app
    ../app/src/: SW356x_v1.7.1.lib
  group user
    ../user/src/: iic_slave_policy.c slave_policy_drive.c source_policy.c i2c_ota_policy.c
  group uvdm
    ../uvdm/: usr_common.c
